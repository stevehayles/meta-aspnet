include 2.1-preview1-revs.inc
include coreclr.inc

PV = "2.1-${CORECLR_BUILD_MAJOR}-${CORECLR_BUILD_MINOR}"